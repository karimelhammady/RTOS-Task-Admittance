# Keil uVision project Proj2.uvproj, settings and files
target Source (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Proj2
  c flags: Optim=1
  c include: ..\RTOS-Task-Admittance;.\include;.\portable\RVDS\ARM_CM3;.\demo_code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FreeRTOS_source
    ./portable/RVDS/ARM_CM3/: port.c
    ./: list.c queue.c tasks.c
    ./portable/MemMang/: heap_1.c
  group Demo_source
    ./: main.c
    ./demo_code/: basic_io.c
  group System_source
    ./: startup_MPS_CM3.s
